Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DFL 6 Wand.IFC
Time: 2022-01-28T09:09:21
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Display D7 - D9 Technik BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: AX3 - DS & BS, Akku LFP3,2V 3h 1,2W; Version 2: AX8 - DS & BS, Akku LFP3,2V 8h 1,2W; Version 3: C- zentr. Vers. AC/DC Adressmodul; Version 4: E - für zentrale Versorgung AC/DC; Version 5: FM3 - AT.DS&BS,LFP3,2V 3h 1,2W RC250; Version 6: FM8 - AT.DS&BS,LFP3,2V 8h 1,2W RC250

# IfcBuildingElementProxy: Display D7-D9 Leuchtmittel BIM_515019020 LM "300" mit 18 Everlight LEDs (2)
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: 6W4 - 6W LED 4000K BLF100%; Version 2: 6W5 - 6W LED 5500K BLF100%

# IfcBuildingElementProxy: Display Gehäuse BIM_DFL 6
In: Default Storey
Material: AL Mg Si 0,5
SolidWorks Custom Properties - Material: AL Mg Si 0,5; Gewicht: 1440.89; Version 1: 0 Ecken abgerundet, IP43 mit LA; Version 2: 2 - Ecken abgerundet, IP54 mit LA; Version 3: 5 - eckige Ausführung IP 32 mit LA; Version 4: 6 - eckige Ausführung IP32 oh. LA; Farbe 1: 0 - silberfarbig eloxiert EV6-01; Farbe 2: 1 - Gehäuse weiß - RAL 9016; Farbe 3: x - Sonderfarbe zuz. Einmalkosten

# IfcBuildingElementProxy: Display Montagefläche BIM_D7-D9
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Display Pikto-Folien BIM
In: Default Storey
Material: PET
SolidWorks Custom Properties - Material: PET; Gewicht: 91.88; Version 1: 00 - ohne Pikto; Version 2: 20 - Piktoset LMU/R/L DIN 7010; Version 3: 24 - Piktoset LM-OR/OL-UR/UL (7010)

# IfcBuildingElementProxy: Display Reflektor BIM_899200850 KD 6 gesperrt!!!
In: Default Storey
Material: PC weiß
SolidWorks Custom Properties - Material: PC weiß

# IfcBuildingElementProxy: Display Scheiben BIM_DFL 6 Scheibe
In: Default Storey
Material: Acrylglas
SolidWorks Custom Properties - Material: Acrylglas; Gewicht: 310.36

# IfcBuildingElementProxy: Display Wandblech BIM_899150055 DFL 6 Wandblech
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12; Gewicht: 1230.25

# IfcElementAssembly: DFL 6 Wand
In: Default Storey
PSet_Mass_Property - Mass Measure: 3.39332; Area Measure: 2.117 m2; Volume Measure: 0.00131831 m3
